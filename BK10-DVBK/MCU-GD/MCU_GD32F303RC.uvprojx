# Keil uVision project MCU_GD32F303RC.uvprojx, settings and files
target BK11-MCU (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BK10-MCU-GD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\inc
  memory RVCT4: ROM 0x800a000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/User
    ./src/: main.c digital.c flash.c interface.c power.c Serial.c Thread.c utils.c canbus.c ds18b20.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:EVAL:GD32F30x 2.1.0, Device:GD32F30x_StdPeripherals:ADC 2.1.0, Device:GD32F30x_StdPeripherals:BKP 2.1.0, Device:GD32F30x_StdPeripherals:CAN 2.1.0, Device:GD32F30x_StdPeripherals:CRC 2.1.0, Device:GD32F30x_StdPeripherals:CTC 2.1.0, Device:GD32F30x_StdPeripherals:DAC 2.1.0, Device:GD32F30x_StdPeripherals:DBG 2.1.0, Device:GD32F30x_StdPeripherals:DMA 2.1.0, Device:GD32F30x_StdPeripherals:ENET 2.1.0, Device:GD32F30x_StdPeripherals:EXMC 2.1.0, Device:GD32F30x_StdPeripherals:EXTI 2.1.0, Device:GD32F30x_StdPeripherals:FMC 2.1.0, Device:GD32F30x_StdPeripherals:FWDGT 2.1.0, Device:GD32F30x_StdPeripherals:GPIO 2.1.0, Device:GD32F30x_StdPeripherals:I2C 2.1.0, Device:GD32F30x_StdPeripherals:MISC 2.1.0, Device:GD32F30x_StdPeripherals:PMU 2.1.0, Device:GD32F30x_StdPeripherals:RCU 2.1.0, Device:GD32F30x_StdPeripherals:RTC 2.1.0, Device:GD32F30x_StdPeripherals:SDIO 2.1.0, Device:GD32F30x_StdPeripherals:SPI_I2S 2.1.0, Device:GD32F30x_StdPeripherals:TIMER 2.1.0, Device:GD32F30x_StdPeripherals:USART 2.1.0, Device:GD32F30x_StdPeripherals:WWDGT 2.1.0, Device:GD32F30x_libopt 2.1.0, Device:Startup 2.1.0
