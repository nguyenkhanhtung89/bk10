# Keil uVision project BK10-RFID.uvprojx, settings and files
target BK10-RFID (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F302RC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BK10-RFID +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xC
  c include: .\inc;.\Drivers\STM32F30x_StdPeriph_Driver\inc;.\Drivers\CMSIS\Device\ST\STM32F30x\Include;.\Drivers\95HF\inc;.\src;.\Drivers\ST7565\Inc;.\Drivers\uGUI
  library: MicroLIB
  memory RVCT4: ROM 0x800a000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/User
    ./src/: main.c Thread.c RFID.c Serial.c utils.c interface.c stm32f30x_it.c
  group 95HF
    ./Drivers/95HF/src/: drv_95HF.c drv_spi.c lib_ConfigManager.c lib_iso15693pcd.c lib_nfctype5pcd.c lib_PCD.c
  group STM32F30x_StdPeriph_Driver
    ./Drivers/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 1.3.0
